# Keil uVision project HAL_TEST.uvprojx, settings and files
target HAL_TEST (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Hal_STM32F10x +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;..\..\0.Library\STM32F1xx_HAL_Driver\Inc;..\..\0.Library\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\0.Library\CMSIS\Device\STM32F1xx\Include;..\..\0.Library\CMSIS\Include;..\Hard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/Inc/: stm32f1xx_hal_conf.h
  group User/Hard
    ../Hard/: LED.c TOF_IIC.c Debug.c OS_Task.c VL6180X.c TOF050.c
  group Lib/STM32F1xx_HAL
    ../../0.Library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Lib/CMSIS
    ../../0.Library/CMSIS/Device/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../0.Library/CMSIS/Device/STM32F1xx/startup/: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.6.0
